# Keil uVision project fire-alarm.uvprojx, settings and files
target fire-alarm (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32L110C6PA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: fire-alarm +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3
  c misc: --c99
  c include: ..\src\app;..\src\config;..\src\driver;..\src\hal\hc32l110;..\..\HC32L110_DDL_Rev1.3.2\driver\inc;..\..\HC32L110_DDL_Rev1.3.2\mcu\common;..\..\HC32L110_DDL_Rev1.3.2\mcu\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group startup
    ./: startup_hc32l110.s
  group common
    ../../HC32L110_DDL_Rev1.3.2/mcu/common/: system_hc32l110.c
  group app
    ../src/app/: pattern_engine.c alarm_sound.c alarm_light.c test_protocol.c
  group config
    ../src/config/: pattern_table.c
  group hal
    ../src/hal/hc32l110/: pwm_drv.c gpio_drv.c uart_drv.c timer_drv.c
  group main
    ../src/: main.c
  group driver
    ../../HC32L110_DDL_Rev1.3.2/driver/src/: ddl.c gpio.c uart.c adt.c clk.c interrupts_hc32l110.c
software components: CMSIS:CORE 6.2.0
